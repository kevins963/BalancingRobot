# IAR project RobotCore.ewp, settings and files
configuration STM32F429I_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\third_party\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\third_party\Drivers\STM32F4xx_HAL_Driver\Inc; ..\third_party\Drivers\BSP\STM32F429I-Discovery; ..\third_party\Drivers\BSP\Components\Common; ..\third_party\Utilities\Log; ..\third_party\Utilities\CPU; ..\third_party\Drivers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32429I_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    Config/: stm32f4xx_hal_conf.h
  group Core
    ./: pid.c pid.h
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../third_party/Drivers/BSP/Components/ili9341/: ili9341.c
    ./: l3gd20h.c l3gd20h.h
    ../third_party/Drivers/BSP/Components/lsm303d/: lsm303d.c lsm303d.h
  group Drivers/BSP/STM32F429I_DISCO
    ../third_party/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_gyroscope.c stm32f429i_discovery_gyroscope.h stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ./: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../third_party/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f429xx.s
  group Example/User
    ./: main.c main.h mems.c mems.h MotorDriver.c MotorDriver.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h
